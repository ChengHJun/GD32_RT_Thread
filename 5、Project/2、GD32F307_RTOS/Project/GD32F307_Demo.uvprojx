# Keil uVision project GD32F307_Demo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F307VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F307_Demo
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F30X_CL
  c include: ..\Code\APP\Inc;..\Code\Core\Inc;..\Code\Data\Inc;..\Code\Drv\Inc;..\Code\Lib\GD32F30x_standard_peripheral\Include;..\Code\Lib\rt-thread\include;..\Code\Lib\rt-thread\bsp
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Core
    ../Code/Core/Src/: gd32f30x_it.c system_gd32f30x.c Sys.c
    ../Code/Core/: startup_gd32f30x_cl.s
    ../Code/Core/Inc/: Sys.h
  group Standard_Pheripheral
    ../Code/Lib/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group RT_Thread
    ../Code/Lib/rt-thread/bsp/: rtconfig.h board.c
    ../Code/Lib/rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
    ../Code/Lib/rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group APP
    ../Code/APP/Src/: main.c
